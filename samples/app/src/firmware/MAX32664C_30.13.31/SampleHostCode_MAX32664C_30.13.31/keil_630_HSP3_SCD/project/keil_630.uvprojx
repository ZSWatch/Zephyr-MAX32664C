# Keil uVision project keil_630.uvprojx, settings and files
target max32630 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MAX32630 Maxim
  pack: Maxim.MAX32630.0.0.1
  cpu: IRAM(0x20000000,0x00080000) IROM(0x00000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: keil_630
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: TARGET=MAX3263x, MXC_ASSERT_ENABLE, TARGET_REV=0x4132, BOARD=EvKit_V1
  c include: ..\app;..\MAX3263XPeriphDriver\Include;..\CMSIS\Include;..\CMSIS\Device\Maxim\MAX3263X\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group app
    ../app/: main.c board.c led.c pb.c stdio.c max20303.c max14690.c
  group driver
    ../MAX3263XPeriphDriver/Source/: adc.c aes.c clkman.c crc.c flc.c gpio.c i2cm.c i2cs.c icc.c ioman.c lp.c maa.c mxc_assert.c mxc_lock.c mxc_sys.c nvic_table.c owm.c pmu.c prng.c pt.c rtc.c spim.c spis.c spix.c tmr.c tmr_utils.c uart.c wdt.c wdt2.c
  group cmsis
    ../CMSIS/Device/Maxim/MAX3263X/Source/: system_max3263x.c
    ../CMSIS/Device/Maxim/MAX3263X/Source/ARM/: startup_max3263x.s
